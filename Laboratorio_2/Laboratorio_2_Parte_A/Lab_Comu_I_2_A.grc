options:
  parameters:
    author: Daniel_Orduz_David_Astro
    generate_options: qt_gui
    id: Prueba00
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud señal
    start: '0'
    step: '1e-2'
    stop: '500e-3'
    value: '500e-3'
  states: {}
- name: 'No'
  id: variable_qtgui_range
  parameters:
    label: Amplitud Ruido
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1e-4'
  states: {}
- name: fcut
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: samp_rate/2
    value: samp_rate/2
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Señal
    start: '1000'
    step: '1000'
    stop: 1e6
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/8
  states: {}
- name: t_band
  id: variable_qtgui_range
  parameters:
    label: 'Banda de transicion '
    start: '0'
    step: '100'
    stop: samp_rate/20
    value: samp_rate/20
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 'No'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\dastr\OneDrive\Documents\UIS\Comunicaciones_I\Lab_Comunicaciones\Laboratorio_2\Parte_A\algomegustadeti_WY.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: t_band
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: '44100'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
